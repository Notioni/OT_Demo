# Keil uVision project STM32L496AGIx.uvprojx, settings and files
target STM32L496AGIx (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L496AGIx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32L496AGIx
  AfterMake: fromelf.exe --bin -o  ./STM32L496AGIx/@L.bin  ./STM32L496AGIx/@L.axf
  c flags: OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L496xx,AOS_SENSOR,AOS_VFS,AOS_FRAMEWORK_COMMON,AOS_UDATA,CONFIG_AOS_FATFS_SUPPORT_MMC
  c misc: --C99 -DSYSINFO_OS_VERSION=\"APP-1.0.0\" -DSYSINFO_PRODUCT_MODEL=\"ALI_AOS_STM32L496AGIx\" -DSYSINFO_DEVICE_NAME=\"STM32LL496AGIx\" -DSYSINFO_KERNEL_VERSION=\"AOS-R-1.1.2\" -DSYSINFO_APP_VERSION=\"APP-1.0.0\" -DSTDIO_UART=0 -DCONFIG_NO_TCPIP -DRHINO_CONFIG_TICK_TASK=0 -DCONFIG_AOS_KV_MULTIPTN_MODE -DCONFIG_AOS_KV_PTN=6 -DCONFIG_AOS_KV_SECOND_PTN=7 -DCONFIG_AOS_KV_PTN_SIZE=4096 -DCONFIG_AOS_KV_BUFFER_SIZE=8192 -D__BSD_VISIBLE -DRHINO_CONFIG_TICK_TASK=0
  c include: ..\..\..\..\include;..\..\..\..\kernel\rhino\core\include;..\..\..\..\platform\arch\arm\armv7m\armcc\m4;..\..\..\..\platform\mcu\stm32l4xx\Drivers\STM32L4xx_HAL_Driver\Inc;..\..\..\..\platform\mcu\stm32l4xx\Drivers\STM32L4xx_HAL_Driver\Inc\Legacy;..\..\..\..\platform\mcu\stm32l4xx\Drivers\CMSIS\Device\ST\STM32L4xx\Include;..\..\..\..\platform\mcu\stm32l4xx\Drivers\CMSIS\Include;..\..\..\..\include\hal;..\..\..\..\kernel\vcall\aos;..\..\..\..\utility\libc\compilers\armlibc;..\..\..\..\example\GUI\STemWin\inc;..\..\..\..\example\GUI\core\include;..\..\..\..\app\GUI\Kids_A20\include;..\..\..\..\app\GUI\Kids_A20\Config;..\..\..\..\platform\mcu\stm32l4xx\src\STM32L496G-Discovery\Kids_A20;..\..\..\..\platform\mcu\stm32l4xx\src\STM32L496G-Discovery\hal;..\..\..\..\kernel\vfs\include;..\..\..\..\kernel\vfs\include\device;..\..\..\..\framework\uData\include;..\..\..\..\kernel\vcall\mico\include;..\..\..\..\device\include;..\..\..\..\kernel\modules\fs\fatfs\include;..\..\..\..\kernel\modules\fs\fatfs\ff\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  link misc: --diag_suppress=L6329
  group platform\mcu\stm32l4xx\Drivers\STM32L4xx_HAL_Driver\Src
    ../../../../platform/mcu/stm32l4xx/Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_dma.c stm32l4xx_hal_pwr.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_i2c.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_tim.c stm32l4xx_hal_rcc.c stm32l4xx_hal_uart.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_dcmi.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_sai.c stm32l4xx_hal_sai_ex.c stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_can.c stm32l4xx_hal_sd.c stm32l4xx_hal_sd_ex.c stm32l4xx_ll_sdmmc.c stm32l4xx_hal_dma2d.c
  group platform\mcu\stm32l4xx\src\STM32L496G-Discovery
    ../../../../platform/mcu/stm32l4xx/src/STM32L496G-Discovery/: startup_stm32l496xx_keil.s
    ../../../../platform/mcu/stm32l4xx/src/STM32L496G-Discovery/Kids_A20/: soc_init.c stm32l4xx_it.c stm32l4xx_hal_msp.c system_stm32l4xx.c st7789.c gc0329.c irda.c isd9160.c audio.c
    ../../../../platform/mcu/stm32l4xx/src/STM32L496G-Discovery/hal/: hal_gpio_stm32l4.c hal_i2c_stm32l4.c hal_uart_stm32l4.c hal_sd_stm32l4.c
  group kernel\rhino\core
    ../../../../kernel/rhino/core/: k_buf_queue.c k_dyn_mem_proc.c k_err.c k_event.c k_fifo.c k_idle.c k_mm.c k_mm_blk.c k_mm_debug.c k_mutex.c k_obj.c k_obj_set.c k_pend.c k_queue.c k_ringbuf.c k_sched.c k_sem.c k_stats.c k_sys.c k_task.c k_task_sem.c k_tick.c k_time.c k_timer.c k_trace.c k_workqueue.c
  group platform\mcu\stm32l4xx\aos
    ../../../../platform/mcu/stm32l4xx/aos/: soc_impl.c trace_impl.c
  group platform\arch\arm\armv7m\armcc\m4
    ../../../../platform/arch/arm/armv7m/armcc/m4/: port_c.c port_c.s
  group main
    ../../../../app/GUI/Kids_A20/: main.c
  group Conf
    ../../../../app/GUI/Kids_A20/Config/: GUIConf.c LCDConf_FlexColor_Template.c
  group GUI\STemWin\OS
    ../../../../example/GUI/STemWin/OS/: GUI_X_rhino.c
  group GUI\STemWin\Lib
    ../../../../example/GUI/STemWin/Lib/: STemWin540_CM4_OS_Keil_ot.lib
  group GUI\core
    ../../../../example/GUI/core/: GUI_init.c
  group app\GUIDEMO
    ../../../../app/GUI/Kids_A20/GUIDEMO/: GUIDEMO.c GUIDEMO_BarGraph.c GUIDEMO_ColorBar.c GUIDEMO_Conf.c GUIDEMO_Graph.c GUIDEMO_Intro.c GUIDEMO_Resource.c GUIDEMO_Start.c GUIDEMO_TransparentDialog.c GUIDEMO_Uncalssified.c
  group kernel\vfs
    ../../../../kernel/vfs/: device.c vfs.c vfs_inode.c vfs_register.c
  group kernel\vcall\aos
    ../../../../kernel/vcall/aos/: aos_rhino.c
  group kernel\yloop
    ../../../../kernel/yloop/: local_event.c yloop.c
  group framework\common
    ../../../../framework/common/: main.c version.c
  group uData
    ../../../../framework/uData/: uData_interface.c uData_main.c
    ../../../../framework/uData/service_mgr/: service_mgr.c
    ../../../../framework/uData/abs_data_model/: abs_data_model.c
    ../../../../framework/uData/cali_data/: calibrated_example_algo.c
  group sensor
    ../../../../kernel/init/: aos_init.c
    ../../../../device/sensor/hal/: sensor_drv_api.c sensor_hal.c
  group device\sensor\drv
    ../../../../device/sensor/drv/: drv_als_ps_liteon_ltr553.c drv_baro_bosch_bmp280.c drv_temp_humi_sensirion_shtc1.c drv_acc_gyro_temp_st_lsm6dsl.c drv_mag_temp_memsic_mmc3680kj.c
  group utility\log
    ../../../../utility/log/: log.c
  group app\CameraDemo
    ../../../../app/GUI/Kids_A20/CameraDemo/: camera_demo.c
  group kernel\modules\fs\fatfs
    ../../../../kernel/modules/fs/fatfs/: diskio.c fatfs.c
    ../../../../kernel/modules/fs/fatfs/ff/: ff.c ffunicode.c
  group app\ATDEMO
    ../../../../app/GUI/Kids_A20/ATDEMO/: atdemo.c
software components: CMSIS:CORE 4.1.0
